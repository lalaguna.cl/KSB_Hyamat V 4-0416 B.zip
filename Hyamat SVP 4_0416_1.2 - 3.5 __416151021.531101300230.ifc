Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: p:/temp/worker_111/temp/exporttempdir_2888_440_bkeov/format_0/Hyamat SVP 4_0416_1.2 - 3.5 __416151021.531101300230.ifc
Time: 2020-05-26T03:10:01
Made in: PARTsolutions

# IfcProject, 4B
Description: Pressure Booster System

# IfcDiscreteAccessory, Hyamat SVP 4/0416/1.2 - 3.5 __416151021.531101300230
In: BUILDING
Description: 4B
Pset_ManufacturerTypeInformation - Manufacturer: KSB; ArticleNumber: Hyamat SVP 4/0416/1.2 - 3.5 __416151021.531101300230
ePset_PARTsolutions - NB: Hyamat SVP 4/0416/1.2 - 3.5 __416151021.531101300230; NN: Hyamat SVP; NT: Pressure Booster System; NBSYN: Hyamat SVP $NOPMP./04$SA./1.2 - 3.5 __$CMPSIZE.$RSA.$MTRCNSTR.$MTRSIZE.$EFFCLS.$RTDPWR.$MTRMTRL.$MTRSRSTYP.$MTRSTL.$MTRSTLFL.$DISTPMP.; LINA: 4B; CATALOG: KSB SE & Co. KGaA; PMPSZE: 4B; NOPMP: 4; SA: 16; CMPSIZE: 0416B; CNNSTDDN1: EN 10226-1; CNNSTDDN2: EN 10226-1; NMNLPRPN1: PN 16; SIZEDN1: R 2"; SIZEDN2: R 2"; MTRPRTCN: IP55; RTDFRQ: 50Hz; MTRPOLE: 2; MTRSIZE: 100L; MTRMFG: KSB; EFFCLS: IE5; RTDPWR: 3 kW; MTRSRSTYP: SuPremE B2
